<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\L6474_selfmade_forward_routine.ewp</path>
  </project>
  <batchBuild />
</workspace>
